## dts/bindings/custom,mpu9250-spi.yaml
```yaml
description: Custom MPU-9250 SPI device (app-level, no driver)
compatible: "custom,mpu9250-spi"
include: [spi-device.yaml]
```
